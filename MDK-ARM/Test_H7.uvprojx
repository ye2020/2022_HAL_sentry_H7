# Keil uVision project Test_H7.uvprojx, settings and files
target Test_H7 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Test_H7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,STM32_THREAD_SAFE_STRATEGY=4
  c include: ../Core/Inc;   ../Drivers/STM32H7xx_HAL_Driver/Inc;   ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;   ../Drivers/CMSIS/Include;   ..\components\SFUD\src;   ..\components\SFUD\port;   ..\components\SFUD\inc;   ..\Control\FDCAN_Receive;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;   ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;   ..\TASK\Task_Detect;   ..\TASK\Task_Fire;   ..\TASK\Task_Led;   ..\TASK\Task_Safe;   ..\SYSTEM\SysInit;   ..\Control\chassis_app;   ..\Control\gimbal_app;   ..\TASK\Task_Chassis;   ..\TASK\Task_Gimbal;   ..\SYSTEM\bsp_usart2;   ..\SYSTEM\FIFO_BUFF;   ..\Control\automatic_strike;   ..\Control\CAN_1_Receive;   ..\Control\CAN_2_Receive;   ..\Control\chassis_behaviour;   ..\Control\gimbal_behaviour;   ..\Control\RemoteControl;   ..\ALGORITHM\math_filter;   ..\ALGORITHM\list_of_function;   ..\ALGORITHM\maths;   ..\ALGORITHM\pid;   ..\ALGORITHM\rmmotor;   ..\REFEREE;   ..\TASK\Task_AboveGimbal
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Control/FDCAN_Receive/: FDCAN_Receive.c
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c rng.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group components/SFUD
    ../components/SFUD/src/: sfud.c sfud_sfdp.c
    ../components/SFUD/port/: sfud_port.c
    ../components/SFUD/inc/: sfud_cfg.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group TASK
    ../TASK/Task_Fire/: Task_Fire.c
    ../TASK/Task_Detect/: Task_Detect.c
    ../TASK/Task_Led/: Task_LED.c
    ../TASK/Task_Safe/: Task_Safe.c
    ../TASK/Task_Chassis/: Task_Chassis.c
    ../TASK/Task_Gimbal/: Task_Gimbal.c
    ../TASK/Task_AboveGimbal/: Task_AboveGimbal.c
  group CONTROL
    ../Control/chassis_app/: chassis_app.c
    ../Control/gimbal_app/: gimbal_app.c
    ../Control/automatic_strike/: automatic_strike.c
    ../Control/CAN_1_Receive/: CAN_1_Receive.c
    ../Control/CAN_2_Receive/: CAN_2_Receive.c
    ../Control/chassis_behaviour/: chassis_behaviour.c
    ../Control/gimbal_behaviour/: gimbal_behaviour.c
    ../Control/RemoteControl/: RemoteControl.c
  group ALGORITHM
    ../ALGORITHM/list_of_function/: list_of_function.h
    ../ALGORITHM/math_filter/: filter.c
    ../ALGORITHM/maths/: maths.c
    ../ALGORITHM/pid/: pid.c
    ../ALGORITHM/rmmotor/: rmmotor.c
  group SYSTEM
    ../SYSTEM/SysInit/: SysInit.c
    ../SYSTEM/bsp_usart2/: bsp_usart2.c
    ../SYSTEM/FIFO_BUFF/: fifo_buff.c
  group REFEREE
    ../REFEREE/: CRC.c RefereeDeal.c UserReferee.c
software components: CMSIS:CORE 5.5.0
